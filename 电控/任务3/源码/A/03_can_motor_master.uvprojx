# Keil uVision project 03_can_motor_master.uvprojx, settings and files
target 03_can_motor_master_n20 (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: 03_can_motor_master_n20 +hex
  c flags: Optim=2 uC99=1 wLevel=3
  c define: STM32F103xB,USE_HAL_DRIVER,ROLE=4
  c misc: -std=c11 -ffunction-sections -fdata-sections
  c include: ..\common_task3;..\..\vendor\STM32CubeF1\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\vendor\STM32CubeF1\Drivers\CMSIS\Include;..\..\vendor\STM32CubeF1\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\common_task3\stm32f103c8.sct
  link misc: --entry Reset_Handler
  group Application
    ../common_task3/: main.c board.c logic.c oled.c
  group HAL
    ../../vendor/STM32CubeF1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_can.c
  group CMSIS
    ../../vendor/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../vendor/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
